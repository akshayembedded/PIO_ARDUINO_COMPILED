## sdkconfig.defaults
```kconfig
CONFIG_ESP_MAIN_TASK_STACK_SIZE=8192
CONFIG_SOC_LCDCAM_I80_LCD_SUPPORTED=n
CONFIG_SOC_LCDCAM_RGB_LCD_SUPPORTED=n
CONFIG_SOC_I2S_SUPPORTED=n
```
